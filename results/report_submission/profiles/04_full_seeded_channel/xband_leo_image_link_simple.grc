options:
  parameters:
    author: Zakariya Alboosh and OpenAI Codex
    category: '[Educational Simulations]'
    description: NOAA-20-inspired X-band LEO image-link physical-layer simulation with external framing and one synchronized receiver.
    generate_options: qt_gui
    id: xband_leo_image_link_simple
    output_language: python
    run_options: run
    title: NOAA-20-Inspired X-Band Image Link — Simple
  states: {}

blocks:
- name: note_system
  id: note
  parameters:
    note: |-
      SYSTEM PARAMETERS — QUICK EDIT
      1. Match image dimensions to simulation_config.json  2. Select rate_scale  3. Select channel_profile  4. Run prepare_image.py  5. Generate and run
  states: {}
- name: rate_scale
  id: variable
  parameters:
    comment: 0.1 practical; 1.0 full NOAA-20-inspired rate
    value: '1.0'
  states: {}
- name: reference_information_rate
  id: variable
  parameters:
    comment: Reference information rate, bit/s
    value: 15e6
  states: {}
- name: carrier_frequency
  id: variable
  parameters:
    comment: Nominal X-band carrier, Hz
    value: 7.812e9
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    comment: Complex samples per QPSK symbol
    value: '2'
  states: {}
- name: rolloff
  id: variable
  parameters:
    comment: RRC excess bandwidth
    value: '0.35'
  states: {}
- name: channel_profile
  id: variable
  parameters:
    comment: 0 clean; 1 Doppler; 2 Doppler+12 dB AWGN; 3 Doppler+5 dB AWGN; 4 full seeded channel
    value: '4'
  states: {}
- name: frame_payload_bytes
  id: variable
  parameters:
    comment: Terminated convolutional-code input frame size
    value: '1024'
  states: {}
- name: payload_bits
  id: variable
  parameters:
    comment: Set by width * height * RGB channels * 8
    value: image_width * image_height * image_channels * 8
  states: {}
- name: training_frames
  id: variable
  parameters:
    comment: Deterministic acquisition frames prepared outside GNU Radio
    value: '4'
  states: {}
- name: mild_snr_db
  id: variable
  parameters:
    comment: Fixed profile-2 sample-domain SNR, dB
    value: '12.0'
  states: {}
- name: moderate_snr_db
  id: variable
  parameters:
    comment: Fixed profile-3 sample-domain SNR, dB
    value: '5.0'
  states: {}
- name: awgn_seed
  id: variable
  parameters:
    comment: Fixed seed for reproducible complex Gaussian noise
    value: '42'
  states: {}
- name: ground_dish_diameter_m
  id: variable
  parameters:
    comment: Representative academic ground dish diameter, m
    value: '2.4'
  states: {}
- name: ground_noise_figure_db
  id: variable
  parameters:
    comment: Representative academic receiver noise figure, dB
    value: '1.0'
  states: {}
- name: image_width
  id: variable
  parameters:
    comment: Must match simulation_config.json
    value: '1024'
  states: {}
- name: image_height
  id: variable
  parameters:
    comment: Must match simulation_config.json
    value: '1024'
  states: {}
- name: image_channels
  id: variable
  parameters:
    comment: RGB8 channels
    value: '3'
  states: {}
- name: information_rate
  id: variable
  parameters:
    comment: Information rate, bit/s
    value: reference_information_rate * rate_scale
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: coded_bit_rate
  id: variable
  parameters:
    comment: Convolutionally encoded rate, bit/s
    value: information_rate / code_rate
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: QPSK symbol rate, symbol/s
    value: coded_bit_rate / bits_per_symbol
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: Complex baseband sample rate, sample/s
    value: symbol_rate * samples_per_symbol
  states: {}
- name: occupied_bandwidth
  id: variable
  parameters:
    comment: Raised-cosine null-to-null bandwidth, Hz
    value: symbol_rate * (1 + rolloff)
  states: {}
- name: frame_bits
  id: variable
  parameters:
    value: frame_payload_bytes * 8
  states: {}
- name: training_bits
  id: variable
  parameters:
    value: training_frames * frame_bits
  states: {}
- name: tail_bits
  id: variable
  parameters:
    value: training_bits
  states: {}
- name: framed_bits
  id: variable
  parameters:
    value: training_bits + payload_bits + tail_bits
  states: {}
- name: rrc_span_symbols
  id: variable
  parameters:
    value: '11'
  states: {}
- name: rrc_ntaps
  id: variable
  parameters:
    comment: Odd tap count gives an integer matched-filter group delay
    value: rrc_span_symbols * samples_per_symbol + 1
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: Receiver RRC matched-filter taps
    value: firdes.root_raised_cosine(1.0, sample_rate, symbol_rate, rolloff, rrc_ntaps)
  states: {}
- name: sync_coded_bit_skip
  id: variable
  parameters:
    comment: Measured deterministic synchronizer acquisition displacement in coded bits
    value: '64'
  states: {}
- name: satellite_tx_gain_db
  id: variable
  parameters:
    value: '5.0'
  states: {}
- name: ground_aperture_efficiency
  id: variable
  parameters:
    value: '0.55'
  states: {}
- name: satellite_tx_power_dbm
  id: variable
  parameters:
    value: '30.0'
  states: {}
- name: ground_noise_temperature_k
  id: variable
  parameters:
    value: '290.0'
  states: {}
- name: grleo_noise_rms
  id: variable
  parameters:
    comment: Seeded profile-4 kTB complex-noise amplitude
    value: (1000 * 1.38e-23 * ground_noise_temperature_k * occupied_bandwidth * 10**(ground_noise_figure_db / 10))**0.5
  states: {}
- name: full_link_voltage_scale
  id: variable
  parameters:
    comment: TX power and antenna voltage gains; sqrt(1000) matches installed gr-leo noise units
    value: 10**((satellite_tx_power_dbm - 30) / 20) * 10**(satellite_tx_gain_db / 20) * ground_aperture_efficiency**0.5 * 3.141592653589793 * ground_dish_diameter_m * carrier_frequency / 299792458.0 * 1000**0.5
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    comment: Profile-4 physical voltage scale; normalized otherwise
    value: full_link_voltage_scale if channel_profile == 4 else 1.0
  states: {}
- name: nominal_sample_power
  id: variable
  parameters:
    comment: Expected normalized TX power after interpolation and x0.5 amplitude control
    value: 0.25 * sum(tap * tap for tap in rrc_taps) / samples_per_symbol
  states: {}
- name: awgn_noise_amplitude
  id: variable
  parameters:
    comment: 0 clean/Doppler; fixed sample-SNR AWGN; seeded kTB for profile 4
    value: 0.0 if channel_profile < 2 else ((nominal_sample_power / 10**((mild_snr_db if channel_profile == 2 else moderate_snr_db) / 10))**0.5 if channel_profile in (2, 3) else grleo_noise_rms)
  states: {}
- name: note_derived_modem
  id: note
  parameters:
    note: DERIVED MODEM RATES, FRAMING, FILTERS AND CODE OBJECTS — NORMALLY DO NOT EDIT
  states: {}
- name: note_leo_configuration
  id: note
  parameters:
    note: X-BAND LINK AND gr-leo CONFIGURATION — CHANNEL ENUMERATIONS, LINK SCALING AND ORBIT OBJECTS
  states: {}
- name: channel_fspl
  id: variable
  parameters:
    comment: 'gr-leo: 0 none, 5 enabled'
    value: 5 if channel_profile == 4 else 0
  states: {}
- name: channel_doppler
  id: variable
  parameters:
    comment: 'gr-leo: 0 none, 7 enabled'
    value: 7 if channel_profile >= 1 else 0
  states: {}
- name: channel_pointing
  id: variable
  parameters:
    comment: 'gr-leo: 0 none, 6 enabled'
    value: 6 if channel_profile == 4 else 0
  states: {}
- name: channel_atmosphere
  id: variable
  parameters:
    comment: 'gr-leo: 0 none, 1 ITU'
    value: 1 if channel_profile == 4 else 0
  states: {}
- name: channel_rain
  id: variable
  parameters:
    comment: 'gr-leo: 0 none, 4 local rainfall rate'
    value: 4 if channel_profile == 4 else 0
  states: {}
- name: channel_noise
  id: variable
  parameters:
    comment: gr-leo internal noise disabled; seeded AWGN is added explicitly
    value: '0'
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    type: qpsk
  states: {}
- name: cc_encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[109, 79]'
    rate: '2'
    state_start: '0'
  states: {}
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_bits
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[109, 79]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: satellite_tx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '55'
    beamwidth: '60'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: carrier_frequency
    gain: satellite_tx_gain_db
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '3'
    value: '"ok"'
  states: {}
- name: satellite_rx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '55'
    beamwidth: '360'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: carrier_frequency
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '3'
    value: '"ok"'
  states: {}
- name: ground_tx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '55'
    beamwidth: '360'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: carrier_frequency
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '3'
    value: '"ok"'
  states: {}
- name: ground_rx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: ground_aperture_efficiency * 100
    beamwidth: '0'
    boom_length: '0'
    circumference: '0'
    diameter: ground_dish_diameter_m
    frequency: carrier_frequency
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '2'
    value: '"ok"'
  states: {}
- name: noaa20_satellite
  id: variable_satellite
  parameters:
    comm_freq_rx: carrier_frequency
    comm_freq_tx: carrier_frequency
    noise_figure: '12'
    noise_temp: '290'
    rx_antenna: satellite_rx_antenna
    rx_bw: occupied_bandwidth
    tle_1: 1 43013U 17073A   26198.87431143  .00000023  00000-0  32041-4 0  9995
    tle_2: 2 43013  98.7772 138.0652 0001490 121.5711 238.5610 14.19516763448824
    tle_title: NOAA 20 / JPSS-1
    tx_antenna: satellite_tx_antenna
    tx_power_dbm: satellite_tx_power_dbm
    value: '"ok"'
  states: {}
- name: zawiya_tracker
  id: variable_tracker
  parameters:
    comm_freq_rx: carrier_frequency
    comm_freq_tx: carrier_frequency
    gs_alt: '0.020'
    gs_lat: '32.75'
    gs_lon: '12.73'
    noise_figure: ground_noise_figure_db
    noise_temp: ground_noise_temperature_k
    obs_end: '2026-07-18T01:03:27.507552Z'
    obs_start: '2026-07-18T01:03:17.507552Z'
    rx_antenna: ground_rx_antenna
    rx_bw: occupied_bandwidth
    satellite_info: noaa20_satellite
    time_resolution_us: '1000'
    tx_antenna: ground_tx_antenna
    tx_power_dbm: '37'
    value: '"ok"'
  states: {}
- name: leo_model
  id: variable_leo_model_def
  parameters:
    atmo_gases_attenuation: channel_atmosphere
    doppler_shift_enum: channel_doppler
    enable_link_margin: 'True'
    fspl_attenuation_enum: channel_fspl
    mode: '1'
    pointing_attenuation_enum: channel_pointing
    precipitation_attenuation: channel_rain
    rainfall_rate: '25'
    surface_watervap_density: '7.5'
    temperature: '20'
    tracker: zawiya_tracker
    value: '"ok"'
  states: {}
- name: note_source
  id: note
  parameters:
    note: IMAGE SOURCE
  states: {}
- name: note_tx
  id: note
  parameters:
    note: TRANSMITTER — RATE-1/2 K=7, DIFFERENTIAL GRAY QPSK, RRC
  states: {}
- name: note_channel
  id: note
  parameters:
    note: X-BAND gr-leo CHANNEL
  states: {}
- name: note_rx
  id: note
  parameters:
    note: SYNCHRONIZED RECEIVER — AGC, MATCHED RRC, FLL, GARDNER, COSTAS
  states: {}
- name: note_output
  id: note
  parameters:
    note: OUTPUT — DECODED LOGICAL BITS
  states: {}
- name: framed_bit_source
  id: blocks_file_source
  parameters:
    file: working/tx_framed_bits.bin
    repeat: 'False'
    type: byte
  states: {}
- name: fec_encoder
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_encoder
    puncpat: '"11"'
    threadtype: none
  states: {}
- name: coded_bits_to_symbols
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '2'
  states: {}
- name: differential_encoder
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: qpsk_mapper
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk_constellation
  states: {}
- name: transmit_rrc
  id: interp_fir_filter_xxx
  parameters:
    interp: samples_per_symbol
    taps: rrc_taps
    type: ccf
  states: {}
- name: amplitude_control
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amplitude / 2.0
    type: complex
  states: {}
- name: simulation_throttle
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: leo_channel
  id: leo_channel_model
  parameters:
    filename: results/channel_log.csv
    model: leo_model
    noise_type: channel_noise
    sample_rate: sample_rate
    store_csv: '1'
  states: {}
- name: deterministic_awgn
  id: analog_noise_source_x
  parameters:
    amp: awgn_noise_amplitude
    noise_type: analog.GR_GAUSSIAN
    seed: awgn_seed
    type: complex
  states: {}
- name: channel_plus_awgn
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: receiver_agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: 1e12
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: matched_rrc
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccf
  states: {}
- name: coarse_fll
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: rolloff
    samps_per_sym: samples_per_symbol
    type: cc
    w: '0.02'
  states: {}
- name: gardner_symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    constellation: qpsk_constellation
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: qpsk_phase_recovery
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: qpsk_decoder
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_constellation
  states: {}
- name: differential_decoder
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: symbols_to_coded_bits
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: coded_alignment
  id: blocks_skiphead
  parameters:
    num_items: sync_coded_bit_skip
    type: byte
  states: {}
- name: hard_bits_to_soft_sign
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: soft_char_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: viterbi_decoder
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder
    puncpat: '"11"'
    threadtype: none
  states: {}
- name: decoded_bit_sink
  id: blocks_file_sink
  parameters:
    file: working/rx_decoded_bits.bin
    type: byte
  states: {}
- name: recovered_constellation_display
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"green"'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Synchronized QPSK symbols
    name: '"Recovered Constellation"'
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: received_spectrum_display
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: sample_rate
    color1: '"red"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: After gr-leo channel
    name: '"Received Spectrum"'
    type: complex
    update_time: '0.1'
    ymin: '-160'
  states: {}

connections:
- [framed_bit_source, '0', fec_encoder, '0']
- [fec_encoder, '0', coded_bits_to_symbols, '0']
- [coded_bits_to_symbols, '0', differential_encoder, '0']
- [differential_encoder, '0', qpsk_mapper, '0']
- [qpsk_mapper, '0', transmit_rrc, '0']
- [transmit_rrc, '0', amplitude_control, '0']
- [amplitude_control, '0', simulation_throttle, '0']
- [simulation_throttle, '0', leo_channel, '0']
- [leo_channel, '0', channel_plus_awgn, '0']
- [deterministic_awgn, '0', channel_plus_awgn, '1']
- [channel_plus_awgn, '0', receiver_agc, '0']
- [channel_plus_awgn, '0', received_spectrum_display, '0']
- [receiver_agc, '0', matched_rrc, '0']
- [matched_rrc, '0', coarse_fll, '0']
- [coarse_fll, '0', gardner_symbol_sync, '0']
- [gardner_symbol_sync, '0', qpsk_phase_recovery, '0']
- [qpsk_phase_recovery, '0', qpsk_decoder, '0']
- [qpsk_phase_recovery, '0', recovered_constellation_display, '0']
- [qpsk_decoder, '0', differential_decoder, '0']
- [differential_decoder, '0', symbols_to_coded_bits, '0']
- [symbols_to_coded_bits, '0', coded_alignment, '0']
- [coded_alignment, '0', hard_bits_to_soft_sign, '0']
- [hard_bits_to_soft_sign, '0', soft_char_to_float, '0']
- [soft_char_to_float, '0', viterbi_decoder, '0']
- [viterbi_decoder, '0', decoded_bit_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
